#ifndef AES128_H
#define AES128_H

#include <stdint.h>
#include <string.h>

#define AES_BLOCK 16
#define AES_ROUNDS 10

/* ---------------------------------------------------------------------
 * S-box. Origem: para cada byte x, calcula-se o inverso multiplicativo
 * em GF(2^8) (modulo x^8+x^4+x^3+x+1; 0 -> 0) e aplica-se a transformacao
 * afim: b'_i = b_i ^ b_(i+4) ^ b_(i+5) ^ b_(i+6) ^ b_(i+7) ^ c_i, c = 0x63.
 * O inverso torna a funcao altamente nao linear; a parte afim elimina
 * pontos fixos. Aqui usamos a tabela pronta (permitido pelo enunciado).
 * --------------------------------------------------------------------- */
static const uint8_t SBOX[256] = {
  0x63,0x7c,0x77,0x7b,0xf2,0x6b,0x6f,0xc5,0x30,0x01,0x67,0x2b,0xfe,0xd7,0xab,0x76,
  0xca,0x82,0xc9,0x7d,0xfa,0x59,0x47,0xf0,0xad,0xd4,0xa2,0xaf,0x9c,0xa4,0x72,0xc0,
  0xb7,0xfd,0x93,0x26,0x36,0x3f,0xf7,0xcc,0x34,0xa5,0xe5,0xf1,0x71,0xd8,0x31,0x15,
  0x04,0xc7,0x23,0xc3,0x18,0x96,0x05,0x9a,0x07,0x12,0x80,0xe2,0xeb,0x27,0xb2,0x75,
  0x09,0x83,0x2c,0x1a,0x1b,0x6e,0x5a,0xa0,0x52,0x3b,0xd6,0xb3,0x29,0xe3,0x2f,0x84,
  0x53,0xd1,0x00,0xed,0x20,0xfc,0xb1,0x5b,0x6a,0xcb,0xbe,0x39,0x4a,0x4c,0x58,0xcf,
  0xd0,0xef,0xaa,0xfb,0x43,0x4d,0x33,0x85,0x45,0xf9,0x02,0x7f,0x50,0x3c,0x9f,0xa8,
  0x51,0xa3,0x40,0x8f,0x92,0x9d,0x38,0xf5,0xbc,0xb6,0xda,0x21,0x10,0xff,0xf3,0xd2,
  0xcd,0x0c,0x13,0xec,0x5f,0x97,0x44,0x17,0xc4,0xa7,0x7e,0x3d,0x64,0x5d,0x19,0x73,
  0x60,0x81,0x4f,0xdc,0x22,0x2a,0x90,0x88,0x46,0xee,0xb8,0x14,0xde,0x5e,0x0b,0xdb,
  0xe0,0x32,0x3a,0x0a,0x49,0x06,0x24,0x5c,0xc2,0xd3,0xac,0x62,0x91,0x95,0xe4,0x79,
  0xe7,0xc8,0x37,0x6d,0x8d,0xd5,0x4e,0xa9,0x6c,0x56,0xf4,0xea,0x65,0x7a,0xae,0x08,
  0xba,0x78,0x25,0x2e,0x1c,0xa6,0xb4,0xc6,0xe8,0xdd,0x74,0x1f,0x4b,0xbd,0x8b,0x8a,
  0x70,0x3e,0xb5,0x66,0x48,0x03,0xf6,0x0e,0x61,0x35,0x57,0xb9,0x86,0xc1,0x1d,0x9e,
  0xe1,0xf8,0x98,0x11,0x69,0xd9,0x8e,0x94,0x9b,0x1e,0x87,0xe9,0xce,0x55,0x28,0xdf,
  0x8c,0xa1,0x89,0x0d,0xbf,0xe6,0x42,0x68,0x41,0x99,0x2d,0x0f,0xb0,0x54,0xbb,0x16
};

/* S-box inversa (usada so na decifragem). */
static const uint8_t INV_SBOX[256] = {
  0x52,0x09,0x6a,0xd5,0x30,0x36,0xa5,0x38,0xbf,0x40,0xa3,0x9e,0x81,0xf3,0xd7,0xfb,
  0x7c,0xe3,0x39,0x82,0x9b,0x2f,0xff,0x87,0x34,0x8e,0x43,0x44,0xc4,0xde,0xe9,0xcb,
  0x54,0x7b,0x94,0x32,0xa6,0xc2,0x23,0x3d,0xee,0x4c,0x95,0x0b,0x42,0xfa,0xc3,0x4e,
  0x08,0x2e,0xa1,0x66,0x28,0xd9,0x24,0xb2,0x76,0x5b,0xa2,0x49,0x6d,0x8b,0xd1,0x25,
  0x72,0xf8,0xf6,0x64,0x86,0x68,0x98,0x16,0xd4,0xa4,0x5c,0xcc,0x5d,0x65,0xb6,0x92,
  0x6c,0x70,0x48,0x50,0xfd,0xed,0xb9,0xda,0x5e,0x15,0x46,0x57,0xa7,0x8d,0x9d,0x84,
  0x90,0xd8,0xab,0x00,0x8c,0xbc,0xd3,0x0a,0xf7,0xe4,0x58,0x05,0xb8,0xb3,0x45,0x06,
  0xd0,0x2c,0x1e,0x8f,0xca,0x3f,0x0f,0x02,0xc1,0xaf,0xbd,0x03,0x01,0x13,0x8a,0x6b,
  0x3a,0x91,0x11,0x41,0x4f,0x67,0xdc,0xea,0x97,0xf2,0xcf,0xce,0xf0,0xb4,0xe6,0x73,
  0x96,0xac,0x74,0x22,0xe7,0xad,0x35,0x85,0xe2,0xf9,0x37,0xe8,0x1c,0x75,0xdf,0x6e,
  0x47,0xf1,0x1a,0x71,0x1d,0x29,0xc5,0x89,0x6f,0xb7,0x62,0x0e,0xaa,0x18,0xbe,0x1b,
  0xfc,0x56,0x3e,0x4b,0xc6,0xd2,0x79,0x20,0x9a,0xdb,0xc0,0xfe,0x78,0xcd,0x5a,0xf4,
  0x1f,0xdd,0xa8,0x33,0x88,0x07,0xc7,0x31,0xb1,0x12,0x10,0x59,0x27,0x80,0xec,0x5f,
  0x60,0x51,0x7f,0xa9,0x19,0xb5,0x4a,0x0d,0x2d,0xe5,0x7a,0x9f,0x93,0xc9,0x9c,0xef,
  0xa0,0xe0,0x3b,0x4d,0xae,0x2a,0xf5,0xb0,0xc8,0xeb,0xbb,0x3c,0x83,0x53,0x99,0x61,
  0x17,0x2b,0x04,0x7e,0xba,0x77,0xd6,0x26,0xe1,0x69,0x14,0x63,0x55,0x21,0x0c,0x7d
};

/* Constantes de rodada: potencias de x (=0x02) em GF(2^8). */
static const uint8_t RCON[10] = {0x01,0x02,0x04,0x08,0x10,0x20,0x40,0x80,0x1b,0x36};

/* xtime: multiplica por x (0x02) em GF(2^8). Desloca 1 bit e, se houve
 * "estouro" do bit 7, reduz pelo polinomio irredutivel (XOR com 0x1b). */
static inline uint8_t xtime(uint8_t a) {
  return (uint8_t)((a << 1) ^ ((a & 0x80) ? 0x1b : 0x00));
}

/* Multiplicacao geral em GF(2^8) por soma de deslocamentos (xtime). */
static inline uint8_t gmul(uint8_t a, uint8_t b) {
  uint8_t p = 0;
  while (b) {
    if (b & 1) p ^= a;
    a = xtime(a);
    b >>= 1;
  }
  return p;
}

/* ---------------------------------------------------------------------
 * Expansao de chave: 16 bytes -> 11 chaves de rodada (176 bytes).
 * roundKeys[16*r .. 16*r+15] e a chave da rodada r.
 * --------------------------------------------------------------------- */
static inline void aes128_expand_key(const uint8_t key[16], uint8_t rk[176]) {
  memcpy(rk, key, 16);
  for (int i = 4; i < 44; i++) {          /* i = indice da palavra (4 bytes) */
    uint8_t t[4];
    memcpy(t, rk + 4 * (i - 1), 4);
    if (i % 4 == 0) {
      /* RotWord + SubWord + Rcon */
      uint8_t tmp = t[0];
      t[0] = SBOX[t[1]] ^ RCON[i / 4 - 1];
      t[1] = SBOX[t[2]];
      t[2] = SBOX[t[3]];
      t[3] = SBOX[tmp];
    }
    for (int j = 0; j < 4; j++) rk[4 * i + j] = rk[4 * (i - 4) + j] ^ t[j];
  }
}

/* --- Transformacoes da cifra --- */

/* AddRoundKey: XOR do estado com a chave de rodada. E a unica etapa que usa
 * a chave; sem ela, o resto seria uma funcao publica e reversivel por todos. */
static inline void add_round_key(uint8_t s[16], const uint8_t *k) {
  for (int i = 0; i < 16; i++) s[i] ^= k[i];
}

/* SubBytes: substitui cada byte pela S-box. Fornece a nao linearidade (confusao). */
static inline void sub_bytes(uint8_t s[16]) {
  for (int i = 0; i < 16; i++) s[i] = SBOX[s[i]];
}

/* ShiftRows: a linha r gira r posicoes a esquerda. Espalha os bytes entre colunas. */
static inline void shift_rows(uint8_t s[16]) {
  uint8_t t[16];
  for (int c = 0; c < 4; c++)
    for (int r = 0; r < 4; r++)
      t[r + 4 * c] = s[r + 4 * ((c + r) % 4)];
  memcpy(s, t, 16);
}

/* MixColumns: cada coluna e multiplicada pela matriz fixa
 *   [2 3 1 1; 1 2 3 1; 1 1 2 3; 3 1 1 2] em GF(2^8). Mistura os 4 bytes da
 * coluna (difusao). Junto com ShiftRows, 2 rodadas espalham 1 byte por todo o bloco. */
static inline void mix_columns(uint8_t s[16]) {
  for (int c = 0; c < 4; c++) {
    uint8_t *col = s + 4 * c;
    uint8_t a0 = col[0], a1 = col[1], a2 = col[2], a3 = col[3];
    col[0] = xtime(a0) ^ (xtime(a1) ^ a1) ^ a2 ^ a3;
    col[1] = a0 ^ xtime(a1) ^ (xtime(a2) ^ a2) ^ a3;
    col[2] = a0 ^ a1 ^ xtime(a2) ^ (xtime(a3) ^ a3);
    col[3] = (xtime(a0) ^ a0) ^ a1 ^ a2 ^ xtime(a3);
  }
}

/* --- Inversas --- */
static inline void inv_sub_bytes(uint8_t s[16]) {
  for (int i = 0; i < 16; i++) s[i] = INV_SBOX[s[i]];
}

static inline void inv_shift_rows(uint8_t s[16]) {
  uint8_t t[16];
  for (int c = 0; c < 4; c++)
    for (int r = 0; r < 4; r++)
      t[r + 4 * ((c + r) % 4)] = s[r + 4 * c];
  memcpy(s, t, 16);
}

/* InvMixColumns: matriz [14 11 13 9; 9 14 11 13; 13 9 14 11; 11 13 9 14]. */
static inline void inv_mix_columns(uint8_t s[16]) {
  for (int c = 0; c < 4; c++) {
    uint8_t *col = s + 4 * c;
    uint8_t a0 = col[0], a1 = col[1], a2 = col[2], a3 = col[3];
    col[0] = gmul(a0,14) ^ gmul(a1,11) ^ gmul(a2,13) ^ gmul(a3, 9);
    col[1] = gmul(a0, 9) ^ gmul(a1,14) ^ gmul(a2,11) ^ gmul(a3,13);
    col[2] = gmul(a0,13) ^ gmul(a1, 9) ^ gmul(a2,14) ^ gmul(a3,11);
    col[3] = gmul(a0,11) ^ gmul(a1,13) ^ gmul(a2, 9) ^ gmul(a3,14);
  }
}

/* --- Cifra e decifra de um bloco de 16 bytes --- */
static inline void aes128_encrypt_block(const uint8_t rk[176], const uint8_t in[16], uint8_t out[16]) {
  uint8_t s[16];
  memcpy(s, in, 16);
  add_round_key(s, rk);
  for (int r = 1; r < AES_ROUNDS; r++) {
    sub_bytes(s);
    shift_rows(s);
    mix_columns(s);
    add_round_key(s, rk + 16 * r);
  }
  sub_bytes(s);                 /* rodada final: sem MixColumns */
  shift_rows(s);
  add_round_key(s, rk + 16 * AES_ROUNDS);
  memcpy(out, s, 16);
}

static inline void aes128_decrypt_block(const uint8_t rk[176], const uint8_t in[16], uint8_t out[16]) {
  uint8_t s[16];
  memcpy(s, in, 16);
  add_round_key(s, rk + 16 * AES_ROUNDS);
  for (int r = AES_ROUNDS - 1; r >= 1; r--) {
    inv_shift_rows(s);
    inv_sub_bytes(s);
    add_round_key(s, rk + 16 * r);
    inv_mix_columns(s);
  }
  inv_shift_rows(s);
  inv_sub_bytes(s);
  add_round_key(s, rk);
  memcpy(out, s, 16);
}

/* ---------------------------------------------------------------------
 * PKCS#7: acrescenta de 1 a 16 bytes, todos iguais ao numero acrescentado.
 * buf deve ter espaco para len + 16 bytes. Retorna o novo tamanho.
 * --------------------------------------------------------------------- */
static inline int pkcs7_pad(uint8_t *buf, int len) {
  int pad = AES_BLOCK - (len % AES_BLOCK);
  for (int i = 0; i < pad; i++) buf[len + i] = (uint8_t)pad;
  return len + pad;
}

/* Retorna o tamanho sem padding, ou -1 se o padding for invalido. */
static inline int pkcs7_unpad(const uint8_t *buf, int len) {
  if (len <= 0 || (len % AES_BLOCK) != 0) return -1;
  int pad = buf[len - 1];
  if (pad < 1 || pad > AES_BLOCK || pad > len) return -1;
  for (int i = 0; i < pad; i++)
    if (buf[len - 1 - i] != pad) return -1;
  return len - pad;
}

#endif /* AES128_H */
